// 此文件由 scripts/generate_analyzer_can_catalog.py 生成，请勿手工修改。
#pragma once

#include <stddef.h>
#include <stdint.h>

namespace analyzer {

constexpr uint16_t kAnalyzerCriticalCanIds[] = {
    0x082, 0x0A9, 0x102, 0x103, 0x107, 0x118, 0x129, 0x132,
    0x145, 0x189, 0x1F9, 0x20C, 0x212, 0x21C, 0x229, 0x238,
    0x243, 0x249, 0x257, 0x25A, 0x25D, 0x266, 0x273, 0x292,
    0x293, 0x2B4, 0x2B6, 0x2E1, 0x2E5, 0x2F3, 0x31F, 0x321,
    0x332, 0x333, 0x334, 0x339, 0x33A, 0x352, 0x370, 0x37A,
    0x389, 0x399, 0x39B, 0x39D, 0x3A1, 0x3B3, 0x3B6, 0x3C2,
    0x3C3, 0x3D2, 0x3D8, 0x3DF, 0x3E2, 0x3E3, 0x3E9, 0x3EA,
    0x3F5, 0x3FD, 0x3FE, 0x401, 0x405, 0x498, 0x4E2, 0x4E3,
    0x4F3, 0x678, 0x679, 0x68C, 0x7FF,
};

constexpr size_t kAnalyzerCriticalCanIdCount =
    sizeof(kAnalyzerCriticalCanIds) / sizeof(kAnalyzerCriticalCanIds[0]);

inline bool isAnalyzerCriticalCanId(uint32_t id)
{
    size_t low = 0;
    size_t high = kAnalyzerCriticalCanIdCount;
    while (low < high)
    {
        const size_t mid = low + (high - low) / 2;
        const uint16_t candidate = kAnalyzerCriticalCanIds[mid];
        if (candidate == id)
            return true;
        if (candidate < id)
            low = mid + 1;
        else
            high = mid;
    }
    return false;
}

}  // namespace analyzer
